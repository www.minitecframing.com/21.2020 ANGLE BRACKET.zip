# Autodesk Inventor assembly: 21.2020 ANGLE BRACKET
## iProperties
Created: 2007-01
Part Number: 21.2020 ANGLE BRACKET
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
